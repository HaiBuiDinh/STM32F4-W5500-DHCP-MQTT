# IAR project Ethernet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: Libraries; Libraries\STM32F4xx_StdPeriph_Driver\inc; Libraries\CMSIS\Include; Libraries\CMSIS\Device\ST\STM32F4xx\Include; inc; Ethernet; Ethernet\W5500; Application\loopback; C:\Users\buidi\OneDrive\Desktop\Congty\PRJ5_3S\STM32F4-W5500-DHCP-MQTT\STM32F4_W5500_DHCP\mqtt; C:\Users\buidi\OneDrive\Desktop\Congty\PRJ5_3S\STM32F4-W5500-DHCP-MQTT\STM32F4_W5500_DHCP\mqtt\MQTT; C:\Users\buidi\OneDrive\Desktop\Congty\PRJ5_3S\STM32F4-W5500-DHCP-MQTT\STM32F4_W5500_DHCP\mqtt\MQTT\MQTTPacket\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Daura.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Ethernet.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group IAR
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group MQTT
    mqtt/: mqtt_func.c
    mqtt/MQTT/: mqtt_interface.c MQTTClient.c
    mqtt/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Std_Lib
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group User
    ./: main.c
    src/: spi_cf.c
    Libraries/: stm32f4xx_it.c
  group Wiz_Lib
    Ethernet/: dhcp.c socket.c wizchip_conf.c
    Ethernet/W5500/: w5500.c
